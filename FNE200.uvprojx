# Keil uVision project FNE200.uvprojx, settings and files
target FNE200 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP
  AfterMake: fromelf.exe --bin -o Objects/app.bin Objects/APP.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=25000000,STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: .\Stm32lib\inc;.\Stm32lib;.\STM32F4xx_HAL_Driver\Inc;.\FlashFs;.\Drivers;.\protocol;.\Source;.\tms_T9_sdk\include;.\USB;.\USB\Include;.\protocol\diagnostic;.\easylogger\inc;.\BSP;.\Task;.\Fun;.\fal\inc;.\FlashDB\inc;.\swd;.\protocol\HCXY_DST
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./Source/: main.c algo_verify .c algo_string.c
  group Task
    ./Task/: task_can.c task_pppd.c task_mon.c task_prtcl.c task_gps.c
  group Fun
    ./Fun/: fun_can.c Fun_Net.c fun_prtcl.c fun_mon.c fun_gps.c
  group Protocol
    ./protocol/: protocol_GB32960.c protocol_GB17691.c analyse_can.c terminal_Server.c
    ./protocol/SXKT_JL/: analyse_Bms_SXKT_JL.c analyse_Bms_SXKT_JL_EX.c protocol_GB_EX_SXKT_JL.c
  group Library
    ./Stm32lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c
  group Drivers
    ./Drivers/: CANSPI.c MCP2515.c stm32f4xx_eeprom.c stm32f4xx_eeprom_hal.c
    ./BSP/: bsp_gps.c
  group FS
    ./FlashFs/: FS_Config.c MCI_STM32F4xx.c retarget_io.c FS_LFN_CM3_L.lib FS_Config_MC_0.h
  group SM2
    ./tms_T9_sdk/source/driver/: driver.c spi.c
    ./tms_T9_sdk/source/function/: basic.c common.c patch.c
    ./tms_T9_sdk/source/function/crypto/: sm2.c
  group USB
    ./USB/: OTG_FS_STM32F4xx.c USBD_Config_0.c USBD_FS_STM32F4xx.c USBD_User_MSC_0.c USB_CM3_L.lib USBD_Config_MSC_0.h
  group UDS
    ./protocol/diagnostic/: NetworkLayer.c Diagnostic.c DiagnosticTimer.c
  group easyLogger
    ./easylogger/src/: elog.c elog_utils.c
    ./easylogger/port/: elog_port.c
  group BSP
    ./BSP/: bsp.c bsp_power.c bsp_io.c bsp_rtc.c bsp_storage.c bsp_wdg.c bsp_uart_fifo.c bsp_can.c bsp_ec20.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:Startup 2.6.3
